# Repository anitaraluca/Proiect_TSC

File README.md:

# Proiect_TSC

## 📊 Diagrama Block

---

##  Descriere Hardware

### 1. Microcontroller – ESP32-C6
- Nucleul sistemului, gestionează toate comunicațiile și logica aplicației.
- Arhitectură RISC-V 32-bit, 160 MHz
- Conectivitate: Wi-Fi 6 (2.4 GHz), Bluetooth 5.0
- GPIO: configurate pentru SPI, I2C, UART, control E-Ink

### 2. Power Management & Baterie
- Baterie Li-Po, 3.7V, 1800mAh
- Circuit de încărcare: MCP73831T
- Alimentare prin USB-C la 5V
- Protecție la supraîncărcare și descărcare profundă
- Regulator LDO 3.3V

### 3. Display – E-Ink 7.5"
- Dimensiune: 7.5 inch
- Rezoluție: 800x480 px
- Comunicare prin SPI

### 4. Port USB-C & Protecție ESD
- Alimentare și transfer de date
- Diodă Schottky și protecție ESD integrată

### 5. RTC – DS3231SN
- Păstrează ora exactă fără alimentare
- Comunicare prin I2C, include baterie de rezervă

### 6. Senzor Ambiental – BME688
- Măsoară temperatură, umiditate, presiune și calitatea aerului
- Comunicare I2C

### 7. Memorie externă – NOR Flash 64MB
- Conectată prin SPI
- Stocare extinsă pentru date și aplicații

### 8. Cititor SD Card
- Comunică prin SPI
- Permite stocare fișiere, jurnalizare și update firmware

### 9. Test Pads
- GPIO: control butoane și I/O general
- SPI: comunicare SD card, Flash și Display
- I2C: senzori și RTC
- UART: debug și serial
- Wi-Fi & Bluetooth: conectivitate wireless

---

##  Pin Mapping

| Componentă                     | Pini ESP32-C6                        | Interfață | Funcționalitate                                                            |
|-------------------------------|--------------------------------------|-----------|----------------------------------------------------------------------------|
| Butoane Control               | IO9 (BOOT), IO15 (CHANGE), EN (RESET) | GPIO      | Interacțiune utilizator                                                    |
| Conexiune USB-C               | GPIO prin regulator                  | USB       | Alimentare + programare ESP32                                              |
| Afișaj E-Paper                | IO7, IO6, IO10, IO5, IO23, IO3       | SPI       | Transfer date imagine + control                                           |
| Senzor BME688                 | IO21 (SDA), IO22 (SCL)               | I2C       | Măsurători ambientale                                                      |
| Modul RTC DS3231             | IO21 (SDA), IO22 (SCL), IO1, IO0, IO18 | I2C       | Timp real                                                                  |
| Flash NOR extern             | IO11 (CS), IO6, IO2, IO7             | SPI       | Memorie aplicație                                                          |
| Cititor MicroSD              | IO7, IO6, IO4, IO2                   | SPI       | Stocare fișiere externe                                                    |
| Monitorizare Baterie         | IO21 (SDA), IO22 (SCL)               | I2C       | Nivel încărcare                                                            |

---

##  Bill of Materials

| Componentă | Datasheet |  Distribuitor |
|------------|----------------------------|-------------------------------|
| CPH3225A | [Datasheet](https://www.snapeda.com/parts/CPH3225A/Seiko%20Instruments/datasheet/) | [Link](https://www.snapeda.com/parts/CPH3225A/Seiko+Instruments/view-part/?ref=eda) |
| TPTP20R | [Datasheet](https://cdn-shop.adafruit.com/product-files/3825/3825_diagram.PDF) | [Link](https://ro.mouser.com/ProductDetail/Adafruit/3825?qs=%252bEew9%252b0nqrAn6n76%252bB5vZg%3D%3D) |
| ESP32C6 Varistor 1812 | [Datasheet](https://www.snapeda.com/parts/RC0603JR-070RL/Yageo/datasheet/) | [Link](https://www.snapeda.com/parts/RC0603JR-070RL/Yageo/view-part/) |
| Capacitor 0402 | [Datasheet](https://componentsearchengine.com/Datasheets/2/CC0402MRX5R5BB106.pdf) | [Link](https://componentsearchengine.com/part-view/CC0402MRX5R5BB106/YAGEO) |
| USB4110-GF-A | [Datasheet](https://gct.co/files/drawings/usb4110.pdf) | [Link](https://componentsearchengine.com/part-view/USB4110-GF-A/GCT%20(GLOBAL%20CONNECTOR%20TECHNOLOGY)) |
| MBR0530 Schottky Diode | [Datasheet](https://www.snapeda.com/parts/MBR0530/ON%20Semiconductor/datasheet/) | [Link](https://www.snapeda.com/parts/MBR0530/Onsemi/view-part/?ref=eda) |
| PGB1010603MR | [Datasheet](https://www.snapeda.com/parts/PGB1010603MR/Littelfuse%20Inc./datasheet/) | [Link](https://www.snapeda.com/parts/PGB1010603MR/Littelfuse/view-part/?ref=eda) |
| MAX17048G+T10 | [Datasheet](https://www.snapeda.com/parts/MAX17048G+T10/Analog%20Devices/datasheet/) | [Link](https://www.snapeda.com/parts/MAX17048G+T10/Analog+Devices/view-part/?ref=eda) |
| QWIIC Connector | [Datasheet](https://www.snapeda.com/parts/PRT-14417/SparkFun%20Electronics/datasheet/) | [Link](https://www.snapeda.com/parts/PRT-14417/SparkFun/view-part/) |
| ESP32C6 WROOM-1-N8 | [Datasheet](https://www.snapeda.com/parts/ESP32-C6-WROOM-1-N8/Espressif%20Systems/datasheet/) | [Link](https://www.snapeda.com/parts/ESP32-C6-WROOM-1-N8/Espressif+Systems/view-part/?ref=eda) |
| RCL CPOL 3528 | [Datasheet](https://s3.amazonaws.com/snapeda/datasheet/TAJB475K025RNJ_AVX.pdf) | [Link](https://www.snapeda.com/parts/TAJB475K025RNJ/AVX/view-part/?ref=dk&t=capacitor%203528&con_ref=None) |
| 744043680 | [Datasheet](https://www.we-online.com/components/products/datasheet/744043680.pdf) | [Link](https://ro.mouser.com/ProductDetail/Wurth-Elektronik/744043680?qs=PGXP4M47uW6VkZq%252BkzjrHA%3D%3D) |
| SI1308EDL-T1-GE3 MOSFET | [Datasheet](https://www.snapeda.com/parts/SI1308EDL-T1-GE3/Vishay%20Siliconix/datasheet/) | [Link](https://www.snapeda.com/parts/SI1308EDL-T1-GE3/Vishay+Siliconix/view-part/?ref=eda) |
| DS3231SN | [Datasheet](https://www.snapeda.com/parts/DS3231SN%23/Analog%20Devices/datasheet/) | [Link](https://www.snapeda.com/parts/DS3231SN%23/Analog+Devices/view-part/?ref=eda) |
| W25Q512JVEIQ | [Datasheet](https://www.winbond.com/resource-files/W25Q512JV%20SPI%20RevB%2006252019%20KMS.pdf) | [Link](https://www.digikey.ro/en/models/10244706) |
| ESP32 WROVER MCP73831 Power Management | [Datasheet](https://www.snapeda.com/parts/MCP73831T-2ACI/OT/Microchip/datasheet/) | [Link](https://www.snapeda.com/parts/MCP73831T-2ACI/OT/Microchip/view-part/) |
| FH34SRJ-24S-0.5SH | [Datasheet](https://www.snapeda.com/parts/FH34SRJ-24S-0.5SH(99)/Hirose%20Connector/datasheet/) | [Link](https://www.snapeda.com/parts/FH34SRJ-24S-0.5SH(99)/Hirose/view-part/) |
| ESP32 WROVER BME680 Sensor | [Datasheet](https://www.bosch-sensortec.com/media/boschsensortec/downloads/datasheets/bst-bme680-ds001.pdf) | [Link](https://www.digikey.ro/en/models/7401317) |
| ESP32 WROVER 0805 Capacitor | [Datasheet](https://ro.mouser.com/datasheet/2/40/schottky-3165252.pdf) | [Link](https://ro.mouser.com/ProductDetail/KYOCERA-AVX/SD0805S020S1R0?qs=jCA%252BPfw4LHbpkAoSnwrdjw%3D%3D) |
| Custom Button | [Datasheet](https://industry.panasonic.com/global/en/downloads?tab=catalog&small_g_cd=203&part_no=EVQPUJ02K) | [Link](https://industry.panasonic.com/global/en/products/control/switch/light-touch/number/evqpuj02k) |
| 112A-TAAR-R03 | [Datasheet](https://www.snapeda.com/parts/112A-TAAR-R03/Attend/datasheet/) | [Link](https://www.snapeda.com/parts/112A-TAAR-R03/Attend/view-part/) |
| LED Chip 0603 | [Datasheet](https://www.snapeda.com/parts/KP-1608SURCK/Kingbright/datasheet/) | [Link](https://grabcad.com/library/0603-smd-led-1) |
| BD5229G-TR | [Datasheet](https://www.rohm.com/datasheet?p=BD5229G&dist=Digi-key&media=referral&source=digi-key.com&campaign=Digi-key) | [Link](https://www.digikey.ee/en/models/658502) |
| USBLC6-2SC6Y | [Datasheet](https://www.snapeda.com/parts/USBLC6-2SC6Y/STMicroelectronics/datasheet/) | [Link](https://www.snapeda.com/parts/USBLC6-2SC6Y/STMicroelectronics/view-part/?ref=eda) |
| XC6220A331MR-G | [Datasheet](https://product.torexsemi.com/system/files/series/xc6220.pdf) | [Link](https://componentsearchengine.com/part-view/XC6220A331MR-G/Torex) |
| Resistor 0402 | [Datasheet](https://www.yageo.com/upload/media/product/products/datasheet/rchip/PYu-RC_Group_51_RoHS_L_12.pdf) | [Link](https://componentsearchengine.com/part-view/R0402%201%25%20100%20K%20(RC0402FR-07100KL)/YAGEO) |

## EAGLE design EBook_Reader/Hardwere/Ebook_Anita_Ghita.brd

Parts:
BOOT_BUTTON: BUTTON_CUSYOMV1; MYBUTTON
C1USB, C2USB1, C6, C21, C22, C24, C25, C26: 100nF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C3BAT, C4BAT, C9BAT, C10BAT: 4.7uF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C5TANT: 100uF; RCL_CT3528
C7: 10uF; ESP32_WROVER_EAGLE-LTSPICE_C0402
C8: 4.7uF/25V; ESP32_WROVER_EAGLE-LTSPICE_C0402
C23: 1uF; ESP32_WROVER_EAGLE-LTSPICE_C0402
CHANGE_BUTTON: BUTTON_CUSYOMV1; MYBUTTON
CHG_LED: ADAFRUIT_LEDCHIP-LED0603; ADAFRUIT_CHIP-LED0603
C_DELAY: 100nF; ESP32_WROVER_EAGLE-LTSPICE_C0402
D1: USBLC6-2SC6Y; SOT95P280X145-6N
D2, D6: ESP32_WROVER_AVX---SD0805S020S1R0_AVX_SD0805S020S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; ESP32_WROVER_AVX---SD0805S020S1R0_AVX_SD0805S020S1R0_0
D3, D4, D5: MBR0530; SOD3716X135N
D7, D8, D9, D10, D11, D12: PGB1010603MR; DIOC1608X36N
EPD_C1, EPD_C2, EPD_C6, EPD_C7, EPD_C8, EPD_C9, EPD_C10, EPD_C11, EPD_C12: 1uF/50V; ESP32_WROVER_EAGLE-LTSPICE_C0402
EPD_C3: 0.1uF/50V; ESP32_WROVER_EAGLE-LTSPICE_C0402
IC1: XC6220A331MR-G; SOT95P280X120-5N
IC2: BD5229G-TR; SOT95P280X125-5N
J1: SAMACSYS_PARTS_USB4110-GF-A; SAMACSYS_PARTS_USB4110GFA
J2: 112A-TAAR-R03_ATTEND; 112ATAARR03ATTEND
J3: FH34SRJ-24S-0.5SH_99_; FH34SRJ24S05SH99
J4: QWIIC_RIGHT_ANGLE; JST04_1MM_RA
L2: 68uH; IND_4828-WE-TPC_WRE
Q1, Q3: 20V/4.2A/52mΩ/1.4W; ESP32_WROVER_SPARKFUN-DISCRETESEMI_SOT23-3
Q2: SI1308EDL-T1-GE3; SOT65P210X110-3N
R1: ESP32C6_VARISTORCN1812; ESP32C6_VARISTOR_CT/CN1812
R2USB, R3USB1: 5K1; ESP32_WROVER_EAGLE-LTSPICE_R0402
R4PWRUSB1: 100K; ESP32_WROVER_EAGLE-LTSPICE_R0402
R5: 2.2; ESP32_WROVER_EAGLE-LTSPICE_R0402
R6, R10, R11_CL1, R12_PINH, R13_PINH, R14_PINH1, R15_PINH1, R16, R17, R18, R19, R20, R21: 10K; ESP32_WROVER_EAGLE-LTSPICE_R0402
R7: 0.47; ESP32_WROVER_EAGLE-LTSPICE_R0402
R8BAT: 200; ESP32_WROVER_EAGLE-LTSPICE_R0402
R9BAT: 2K; ESP32_WROVER_EAGLE-LTSPICE_R0402
RESET_BUTTON: BUTTON_CUSYOMV1; MYBUTTON
R_BOOT: 10K; ESP32_WROVER_EAGLE-LTSPICE_R0402
R_CAPACITOR: 15; ESP32_WROVER_EAGLE-LTSPICE_R0402
R_CHANGE: 10K; ESP32_WROVER_EAGLE-LTSPICE_R0402
R_RESET: 10K; ESP32_WROVER_EAGLE-LTSPICE_R0402
SENSOR2: ESP32_WROVER_BME680_BME680; ESP32_WROVER_BME680_PSON80P300X300X100-8N
SJ1: SJ
SUPERCAP: CPH3225A; CAPCP3225X100N
TP_3V3: TPTP20R; TP20R
TP_EPD_3V3, TP_EPD_3V3_C: TPTP20R; TP20R
TP_EPD_BUSY: TPTP20R; TP20R
TP_EPD_CS: TPTP20R; TP20R
TP_EPD_DC: TPTP20R; TP20R
TP_EPD_RST: TPTP20R; TP20R
TP_GND, TP_GND1: TPTP20R; TP20R
TP_INT_RTC: TPTP20R; TP20R
TP_MISO: TPTP20R; TP20R
TP_MOSI: TPTP20R; TP20R
TP_RX: TPTP20R; TP20R
TP_SCK: TPTP20R; TP20R
TP_TX: TPTP20R; TP20R
TP_VBAT: TPTP20R; TP20R
TP_VBUS: TPTP20R; TP20R
U1: ESP32_WROVER_SPARKFUN-IC-POWER_MCP73831; ESP32_WROVER_SPARKFUN-IC-POWER_SOT23-5
U2: ESP32-C6-WROOM-1-N8; XCVR_ESP32-C6-WROOM-1-N8
U4: MAX17048G+T10; SON50P200X200X80-9N
U5: DS3231SN#; SOIC127P1032X265-16N
U6: W25Q512JVEIQ; SON127P600X800X80-9N

Connections:
3V3: C4BAT.1, C5TANT.+, C6.2, D6.2 (ANODE), IC1.5 (VOUT), IC2.2 (VDD), J2.P4 (VDD), J4.2, Q3.3 (D), R10.2, R11_CL1.2, R14_PINH1.2, R15_PINH1.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R_BOOT.2, R_CHANGE.2, R_RESET.2, TP_3V3.TP, U2.2 (3V3), U5.2 (VCC), U6.3 (!WP!(IO2)), U6.7 (!HOLD!/!RESET!(IO3)), U6.8 (VCC)
32KHZ: R14_PINH1.1, U2.9 (IO1), U5.1 (32KHZ)
DN: D1.4 (I/O2_2), J1.A7, J1.B7
DP: D1.6 (I/O1_2), J1.A6, J1.B6
EPD_3V3: C7.1, EPD_C3.2, J3.15, J3.16, L2.2, Q3.2 (S), TP_EPD_3V3.TP
EPD_3V3_C: Q3.1 (G), R11_CL1.1, TP_EPD_3V3_C.TP, U2.18 (IO20)
EPD_BUSY: J3.9, TP_EPD_BUSY.TP, U2.26 (IO3)
EPD_CS: D11.1, J3.12, R20.1, TP_EPD_CS.TP, U2.11 (IO10)
EPD_DC: J3.11, TP_EPD_DC.TP, U2.5 (IO5)
EPD_RST: J3.10, TP_EPD_RST.TP, U2.21 (IO23)
FLASH_CS: D10.1, R19.1, U2.12 (IO11), U6.1 (!CS)
GDR: J3.2, Q2.1 (G), R6.2
GND: BOOT_BUTTON.1, BOOT_BUTTON.2, C1USB.2, C2USB1.2, C3BAT.2, C4BAT.2, C5TANT.-, C6.1, C7.2, C9BAT.2, C10BAT.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, CHANGE_BUTTON.1, CHANGE_BUTTON.2, C_DELAY.2, D1.2 (GND), D5.1 (K), D7.2, D8.2, D9.2, D10.2, D11.2, D12.2, EPD_C1.1, EPD_C2.1, EPD_C3.1, EPD_C6.1, EPD_C7.1, EPD_C8.1, EPD_C9.1, EPD_C10.1, EPD_C11.1, EPD_C12.1, IC1.2 (VSS), IC2.3 (GND), J1.A1, J1.A12, J1.B1, J1.B12, J1.MP1, J1.MP2, J1.MP3, J1.MP4, J2.G1 (GND_1), J2.G2 (GND_2), J2.G3 (GND_3), J2.G4 (GND_4), J2.P6 (VSS), J3.8, J3.17, J3.MP1, J3.MP2, J4.1, R2USB.1, R3USB1.2, R4PWRUSB1.1, R5.1, R6.1, R9BAT.1, RESET_BUTTON.1, RESET_BUTTON.2, SENSOR2.1 (GND), SENSOR2.5 (SDO), SENSOR2.7 (GND), SJ1.1, SUPERCAP.2, TP_GND.TP, TP_GND1.TP, U1.2 (VSS), U2.1 (GND), U2.28 (GND), U2.29_1 (GND), U2.29_2 (GND), U2.29_3 (GND), U2.29_4 (GND)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
GPIO8: R10.1, U2.10 (IO8)
I2C_PW: C21.1, C22.1, R12_PINH.2, R13_PINH.2, SENSOR2.2 (CSB), SENSOR2.6 (VDDIO), SENSOR2.8 (VDD), U2.17 (IO19)
INT_RTC: R15_PINH1.1, TP_INT_RTC.TP, U2.8 (IO0), U5.3 (SQW/!INT)
IO/BOOT: BOOT_BUTTON.3, BOOT_BUTTON.4, C24.1, R_BOOT.1, U2.15 (IO9)
IO/CHANGE: C25.1, CHANGE_BUTTON.3, CHANGE_BUTTON.4, R_CHANGE.1, U2.23 (IO15)
MISO: D7.1, J2.P7 (DAT0), R16.1, TP_MISO.TP, U2.27 (IO2), U6.2 (DO(IO1))
MOSI: D8.1, J2.P3 (CMD), J3.14, R17.1, TP_MOSI.TP, U2.7 (IO7), U6.5 (DI(IO0))
unnamed: J1.A5, R2USB.2
unnamed: EPD_C6.2, J3.18
unnamed: EPD_C1.2, J3.4
unnamed: C3BAT.1, D2.1 (CATHODE), IC1.1 (VIN), IC1.3 (CE), Q1.2 (S)
unnamed: C8.1, D4.1 (K), D5.2 (A)
unnamed: R8BAT.2, U1.1 (STAT)
unnamed: CHG_LED.C, R8BAT.1
unnamed: R9BAT.2, U1.5 (PROG)
unnamed: EPD_C2.2, J3.5
unnamed: J1.B5, R3USB1.1
unnamed: EPD_C7.2, J3.19
unnamed: EPD_C8.2, J3.20
unnamed: C_DELAY.1, IC2.5 (CT)
unnamed: EPD_C10.2, J3.22
unnamed: D6.1 (CATHODE), R_CAPACITOR.2
unnamed: EPD_C12.2, J3.24
PREVGH: D3.1 (K), EPD_C9.2, J3.21
PREVGL: D4.2 (A), EPD_C11.2, J3.23
RESE: J3.3, Q2.2 (S), R7.2
RESE': R5.2, R7.1, SJ1.2
RESET: C23.1, IC2.1 (VOUT), RESET_BUTTON.3, RESET_BUTTON.4, R_RESET.1, U2.3 (EN)
RTC_RST: U2.16 (IO18), U5.4 (!RST)
RX: TP_RX.TP, U2.24 (RXD0/GPIO17)
SCK: D9.1, J2.P5 (CLK), J3.13, R18.1, TP_SCK.TP, U2.6 (IO6), U6.6 (CLK)
SCL: J4.4, R12_PINH.1, SENSOR2.4 (SCK), U2.20 (IO22), U4.7 (SCL), U5.16 (SCL)
SDA: J4.3, R13_PINH.1, SENSOR2.3 (SDI), U2.19 (IO21), U4.8 (SDA), U5.15 (SDA)
SRC: C8.2, D3.2 (A), L2.1, Q2.3 (D)
SS_SD: D12.1, J2.P2 (CD/DAT3), R21.1, U2.4 (IO4)
TX: TP_TX.TP, U2.25 (TXD0/GPIO16)
USB_D+: D1.1 (I/O1_1), U2.14 (IO13)
USB_D-: D1.3 (I/O2_1), U2.13 (IO12)
VBAT: C10BAT.1, Q1.3 (D), TP_VBAT.TP, U1.3 (VBAT), U4.2 (CELL), U4.3 (VDD)
VBUS: C1USB.1, C2USB1.1, C9BAT.1, CHG_LED.A, D1.5 (VBUS), D2.2 (ANODE), Q1.1 (G), R1.2, R4PWRUSB1.2, TP_VBUS.TP, U1.4 (VIN)
VRTC: C26.1, R_CAPACITOR.1, SUPERCAP.1, U5.14 (VBAT)
VUSB: J1.A4, J1.A9, J1.B4, J1.B9, R1.1

Notes on the sheet:
USB C connector & ESD protection
LDO Voltage Regulator
SD Card
ESP32 C6
Li-Po Battery Charging Controller
E-Paper Drive Circuit
Display Type Selector
E-Paper Display Header
EPD Power
Environmental Sensor BME688
Voltage Supervisor + Reset & Boot / IO Button
Battery ChargeLevel
External NORFlash64MB
SPI ESD Protection Lines
Qwiic / Stemma QT
Test Pads
RTC Module DS3231SN

Board: 2 copper layers, 170.2 x 111.2 mm, 103 parts (0 on the bottom side), 55 nets.

## Commit log

2025-04-06 Create LICENSE
2025-04-06 README.md
2025-04-16 Create Mechanical

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2024 Ultra Librarian. All rights reserved.
